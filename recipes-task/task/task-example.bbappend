
do_taskExample:prepend(){
    bbwarn "Hello from do_taskExample Prepend "
}

do_taskExample:append(){
    bbwarn "Hello from do_taskExample Append "
}
